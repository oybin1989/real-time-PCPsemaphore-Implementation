# Keil uVision project RavenOSV2Demo.uvprojx, settings and files
target RavenOS Demo (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: CU_SYSC4906.LabF14_DFP.1.0.7
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RavenOS +hex
  c flags: Optim=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM TM4C123GH6PM
  c include: .\RTE\RTOS\Include;.\RTE\Application\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group RavenOS Source
    ./RTE/RTOS/Source/: retarget.c peripherals.c trace.c kernel.c threads.c semaphores.c threadIdle.c protectedTrace.c
  group Application
    ./RTE/Application/source/: sem1.c
    ./: sem2.c thread1.c thread2.c thread3.c thread4.c thread5.c main.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, CMSIS Driver:USART:TM4C123GH6PM 2.01
